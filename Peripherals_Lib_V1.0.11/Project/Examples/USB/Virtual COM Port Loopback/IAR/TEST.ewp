# IAR project TEST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\HC32F4xx_Peripherals_Driver\inc; ..\..\..\..\..\Libraries\CMSIS\Device\Holychip\HC32F401\Include; ..\; ..\inc; ..\USB-FS-Device_Driver\inc; $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: TEST.srec
  ILINK.IlinkOutputFile: TEST.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_Holychip#HC32F4XX#1.0.7}$\.iar\config\linker\HC32F401BRCX.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../Libraries/CMSIS/Include/: core_cm4.h
    ../../../../../Libraries/CMSIS/Device/Holychip/HC32F401/Source/: system_hc32f4xx.c
  group EWARM
    ../../../../../Libraries/CMSIS/Device/Holychip/HC32F401/Source/iar/: startup_hc32f401xxx.s
  group EWFIB
    ../../../../../Libraries/HC32F4xx_Peripherals_Driver/src/: hc32f4xx_adc.c hc32f4xx_canfd.c hc32f4xx_crc.c hc32f4xx_dac.c hc32f4xx_dbgmcu.c hc32f4xx_dma.c hc32f4xx_exti.c hc32f4xx_fda.c hc32f4xx_flash.c hc32f4xx_gpio.c hc32f4xx_i2c.c hc32f4xx_i2s.c hc32f4xx_iwdg.c hc32f4xx_mou.c hc32f4xx_pwr.c hc32f4xx_rcc.c hc32f4xx_rtc.c hc32f4xx_spi.c hc32f4xx_syscfg.c hc32f4xx_tim.c hc32f4xx_tim10.c hc32f4xx_usart.c hc32f4xx_vc.c hc32f4xx_wwdg.c misc.c
  group UsbDriver
    ../USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USER
    ../: hc32f4xx_it.c main.c
    ../src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
