# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F401BRCX Holychip
  pack: Holychip.HC32F4XX.1.0.7
  cpu: IRAM(0x20000000,0x00030000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --C99
  c include: ..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\CMSIS\Device\Holychip\HC32F401\Include;..\..\..\..\..\Libraries\HC32F4xx_Peripherals_Driver\inc;..\..\MOU Convolution
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  group User
    ../: main.c hc32f4xx_it.c
  group CMSIS
    ../../../../../Libraries/CMSIS/Device/Holychip/HC32F401/Source/: system_hc32f4xx.c
  group Driver
    ../../../../../Libraries/HC32F4xx_Peripherals_Driver/src/: hc32f4xx_adc.c hc32f4xx_canfd.c hc32f4xx_crc.c hc32f4xx_dac.c hc32f4xx_dbgmcu.c hc32f4xx_dma.c hc32f4xx_exti.c hc32f4xx_fda.c hc32f4xx_flash.c hc32f4xx_gpio.c hc32f4xx_i2c.c hc32f4xx_i2s.c hc32f4xx_iwdg.c hc32f4xx_pwr.c hc32f4xx_rcc.c hc32f4xx_rtc.c hc32f4xx_spi.c hc32f4xx_syscfg.c hc32f4xx_tim.c hc32f4xx_tim10.c hc32f4xx_usart.c hc32f4xx_vc.c hc32f4xx_wwdg.c misc.c hc32f4xx_mou.c
  group MDKARM
    ../../../../../Libraries/CMSIS/Device/Holychip/HC32F401/Source/arm/: startup_hc32f40_41xxx.s
